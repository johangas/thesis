IMAGE_INSTALL += "native-border-router libcoap"
IMAGE_INSTALL += "radvd"
IMAGE_INSTALL += "lwm2m-server"
IMAGE_INSTALL += "bootstrap-server"
IMAGE_INSTALL += "lwm2m-server-dtls"
IMAGE_INSTALL += "tinydtls"

